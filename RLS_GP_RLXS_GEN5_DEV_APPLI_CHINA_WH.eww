<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RLS_GP_RLXS_GEN5_DEV_APPLI_CHINA_WH.ewp</path>
  </project>
  <batchBuild/>
</workspace>


