# IAR project vcast_debug.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F10PGJ RL78 - R5F10PGJ
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f10pgj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: vcast_harness.d43
