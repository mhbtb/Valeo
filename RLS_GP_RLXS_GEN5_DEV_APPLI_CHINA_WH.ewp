# IAR project RLS_GP_RLXS_GEN5_DEV_APPLI_CHINA_WH.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F109BE RL78 - R5F109BE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 512
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: AUDI_B8_KS; _DEBUG_
  ICCRL78.CCIncludePath2: .; ..; Rain; SelfProgLibrary; LIN; X1_Humidity; Diagnostics; Peripherals; CustomerInterface; Light; OS; EEPROM; Device
  XLINK.XclFile: G5_Appli_lnkr5f109be.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: AUDI_B8_KS
configuration ChangAn_S311_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: CHANG_AN_S311
configuration ChangAn_S311_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: CHANG_AN_S311; _DEBUG_
configuration Chery_T1A_35A_Standby_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: Chery_T1A_35A_Standby
configuration Chery_T1A_35A_Standby_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: Chery_T1A_35A_Standby; _DEBUG_
configuration BYD_HC_SA3F_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: BYD_HC
configuration BYD_HC_SA3F_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: BYD_HC; _DEBUG_
  group CustomerInterface
    CustomerInterface/: G5_AsicFramesLin.c G5_linconf_Fiat_330.h G5_rainsens.c G5_RLS_LIN.c G5_RLS_LIN_BAICYX_G20.c G5_RLS_LIN_BRILLIANCE_M8X.c G5_RLS_LIN_BYD_HC.c G5_RLS_LIN_C6.c G5_RLS_LIN_CHANGAN_S311.c G5_RLS_LIN_Chery_T1A_3.5A_STANDBY.c G5_RLS_LIN_CTCS_M31T.c G5_RLS_LIN_Faraday.c G5_RLS_LIN_Ferrari.c G5_RLS_LIN_FIAT940.c G5_RLS_LIN_FIAT_330.c G5_RLS_LIN_Ford.c G5_RLS_LIN_Foton_S700.c G5_RLS_LIN_GEELY.c G5_RLS_LIN_HAITEC.c G5_RLS_LIN_Tesla.c G5_RLS_LINcommon.c
  group Diagnostics
    Diagnostics/: G5_Check_sr.c G5_Diagnose.c G5_I2CDebug.c G5_ictest.c
  group EEPROM
    EEPROM/: G5_E2Handler.c G5_FlashE2.c
  group Light
    Light/: G5_DippedBeam_sr.c G5_irlight.c G5_IRlight41_ca.c G5_IRlight_se.c G5_irlightNoLS.c G5_TwilightToDark.c
  group LIN
    LIN/: G5_LINsci_sr.c G5_rls.c G5_rls940.c G5_rls_BAICYX_G20.c G5_rls_BRILLIANCE_M8X.c G5_rls_BYD_HC.c G5_rls_CHANGAN_S311.c G5_rls_Chery_T1A_3.5A_STANDBY.c G5_rls_CTCS_M31T.c G5_rls_Faraday.c G5_rls_Ferrari.c G5_rls_Fiat_330.c G5_rls_Fiat_330.h G5_rls_ford.c G5_rls_FOTON_S700.c G5_rls_Tesla.c G5_rlsC6.c G5_rlsGeely.c G5_rlsHAITEC.c
  group OS
    OS/: G5_Appli_Lowinit.c G5_Appli_main.c G5_Appli_timer.c G5_utilities.c
  group Peripherals
    Peripherals/: G5_ASIC_Control.c G5_ASIC_Control_sr.c G5_io.c G5_spi_sr.c
  group Rain
    Rain/: G5_rs_betrieb.c G5_rs_empf.c G5_rs_intber.c G5_rs_mem_40.c G5_rs_motor.c G5_rs_sig_min.c G5_rs_signal.c G5_RS_Task.c G5_rs_thold.c
  group SelfProgLibrary
    SelfProgLibrary/: pfdl.h pfdl.inc pfdl.r87 pfdl_types.h
  group X1_Humidity
    X1_Humidity/: G5_HumTemp.c
