# IAR project RLS_GP_RLXS_GEN5_DEV_APPLI_CHINA.ewp, settings and files
configuration Zotye_A40_Release (RL78)
  General.GenDeviceSelect: R5F109BE RL78 - R5F109BE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 512
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: ZOTYE_A40
  ICCRL78.CCIncludePath2: .; ..; Rain; SelfProgLibrary; LIN; X1_Humidity; Diagnostics; Peripherals; CustomerInterface; Light; OS; EEPROM; Device
  XLINK.XclFile: G5_Appli_lnkr5f109be.xcl
  XLINK.XlinkStackSize: 1
configuration ZOTYE_A40_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: ZOTYE_A40; _DEBUG_
configuration DFLQ_RLFSS_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: DFLQ_RLFSS
configuration DFLQ_RLFSS_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: DFLQ_RLFSS; _DEBUG_
configuration Zoety_A10_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: Zoety_A10
configuration Zoety_A10_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: Zoety_A10; _DEBUG_
configuration Chery_T18_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: Chery_T18
configuration Chery_T18_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: Chery_T18; _DEBUG_
configuration CHJ_M01_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: CHJ_M01
configuration CHJ_M01_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: CHJ_M01; _DEBUG_
configuration Chery_KX63_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: Chery_KX63
configuration Chery_KX63_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: Chery_KX63; _DEBUG_
configuration Great_Wall_CH071 (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: GREAT_WALL_CH071
configuration Great_Wall_CH071_Debug (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: GREAT_WALL_CH071; _DEBUG_
configuration GEELY_FS11_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: GEELY_FS11
configuration GEELY_FS11_Debug (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: GEELY_FS11; _DEBUG_
configuration GEELY_FS11_NOLIGHT_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: GEELY_FS11_NOLIGHT
configuration GEELY_FS11_NOLIGHT_Debug (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: GEELY_FS11_NOLIGHT; _DEBUG_
configuration ZOTYE_B01_NEW_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: ZOTYE_B01_NEW
configuration ZOTYE_B01_NEW_Debug (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: ZOTYE_B01_NEW; _DEBUG_
configuration BYTON_Rel (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: BYTON
configuration BYTON_Dbg (RL78, debug)
  as the first configuration, except:
  ICCRL78.CCDefines: BYTON; _DEBUG_
configuration GEELY2.0_Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: GEELY2DOT0
configuration GEELY2.0_Debug (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: GEELY2DOT0; _DEBUG_
  group CustomerInterface
    CustomerInterface/: G5_AsicFramesLin.c G5_rainsens.c G5_RLS_LIN.c G5_RLS_LIN_BAICYX_G20.c G5_RLS_LIN_BAICYX_H50.c G5_RLS_LIN_BRILLIANCE_M8X.c G5_RLS_LIN_BYTON.c G5_RLS_LIN_C6.c G5_RLS_LIN_Chery_KX63.c G5_RLS_LIN_Chery_T18.c G5_RLS_LIN_CHJ_M01.c G5_RLS_LIN_CTCS_M31T.c G5_RLS_LIN_DFLQ_RLFSS.c G5_RLS_LIN_Faraday.c G5_RLS_LIN_Ferrari.c G5_RLS_LIN_FIAT940.c G5_RLS_LIN_Ford.c G5_RLS_LIN_Foton_S700.c G5_RLS_LIN_GEELY.c G5_RLS_LIN_GEELY2DOT0.c G5_RLS_LIN_GEELY_FS11.c G5_RLS_LIN_GEELY_FS11_NoLight.c G5_RLS_LIN_GEELY_NL_3A.c G5_RLS_LIN_GEELY_NL_5.c G5_RLS_LIN_Great_Wall_CH071.c G5_RLS_LIN_HAITEC.c G5_RLS_LIN_Tesla.c G5_RLS_LIN_Zoety_A10.c G5_RLS_LIN_ZOTYE_A40.c G5_RLS_LIN_ZOTYE_B01_NEW.c G5_RLS_LINcommon.c
  group Diagnostics
    Diagnostics/: G5_Check_sr.c G5_Diagnose.c G5_I2CDebug.c G5_ictest.c
  group EEPROM
    EEPROM/: G5_E2Handler.c G5_FlashE2.c
  group Light
    Light/: G5_DippedBeam_sr.c G5_irlight.c G5_IRlight41_ca.c G5_IRlight_se.c G5_irlightNoLS.c G5_TwilightToDark.c
  group LIN
    LIN/: G5_LINsci_sr.c G5_rls.c G5_rls940.c G5_rls_BAICYX_G20.c G5_rls_BAICYX_H50.c G5_rls_BRILLIANCE_M8X.c G5_rls_BYTON.c G5_rls_Chery_KX63.c G5_rls_Chery_T18.c G5_rls_CHJ_M01.c G5_rls_CTCS_M31T.c G5_rls_DFLQ_RLFSS.c G5_rls_Faraday.c G5_rls_Ferrari.c G5_rls_ford.c G5_rls_FOTON_S700.c G5_rls_GEELY2DOT0.c G5_rls_GEELY_FS11.c G5_rls_GEELY_FS11_NoLight.c G5_rls_Geely_NL_3A.c G5_rls_Great_Wall_CH071.c G5_rls_NL_5.c G5_rls_Tesla.c G5_rls_Zoety_A10.c G5_rls_ZOTYE_A40.c G5_rls_ZOTYE_B01_NEW.c G5_rlsC6.c G5_rlsGeely.c G5_rlsHAITEC.c
  group OS
    OS/: G5_Appli_Lowinit.c G5_Appli_main.c G5_Appli_timer.c G5_utilities.c
  group Peripherals
    Peripherals/: G5_ASIC_Control.c G5_ASIC_Control_sr.c G5_io.c G5_spi_sr.c
  group Rain
    Rain/: G5_rs_betrieb.c G5_rs_empf.c G5_rs_intber.c G5_rs_mem_40.c G5_rs_motor.c G5_rs_sig_min.c G5_rs_signal.c G5_RS_Task.c G5_rs_thold.c
  group SelfProgLibrary
    SelfProgLibrary/: pfdl.h pfdl.inc pfdl.r87 pfdl_types.h
  group X1_Humidity
    X1_Humidity/: G5_HumTemp.c
